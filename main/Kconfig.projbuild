## main/Kconfig.projbuild
```kconfig
menu "3-LED Controller Configuration"

    orsource "$IDF_PATH/examples/common_components/env_caps/$IDF_TARGET/Kconfig.env_caps"

endmenu
```
